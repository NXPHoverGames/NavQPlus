FILESEXTRAPATHS:prepend := "${THISDIR}/u-boot-imx:"

SRC_URI += " \
	file://0001-uboot-2204-changes-navqplus-3.patch \
"

SRCREV = "1c881f4da83cc05bee50f352fa183263d7e2622b"
